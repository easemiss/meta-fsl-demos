# This image extends fsl-image-multimedia with additional
# gstreamer plugins

require fsl-image-multimedia.bb

